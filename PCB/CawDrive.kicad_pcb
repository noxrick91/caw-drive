# Repository noxrick91/caw-drive

File README.md:

使用说明：https://noxcaw.com/t/topic/20

## KiCad design PCB/CawDrive.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C11, C12, C13, C14, C17, C18: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C9: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C19: 0.1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CN2: WAFER-SH1.0-6PWB; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
CN3: WAFER-SH1.0-4PWB; CONN-SMD_4P-P1.00_WAFER-SH1.0-4PWB
D1: MCU_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D2: DRV_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D4: PWR_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D6: ENCODER_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via; not fitted
H8, H9: MountingHole_Pad; POWER_PAD; not fitted
L1: 39nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
Q1: NMOS; SOT-723
R1, R20: 10k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2, R3, R5, R6, R10, R22: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R24: 0Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R9, R11, R15: 510Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8: 75k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12: 3k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 10k NTC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23, R25: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R26: 120Ω 1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint; TestPoint_Pad_D1.0mm
TV1: SMAJ36CA/TR13; SMAJ36CA_TR13_SMA(DO-214AC); JLC Part Number C87270
U1: TJA1051T/3/1J; TJA1051T31J_SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL
U5, U6, U10, U11, U12: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
U8: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U9: MT6835GT-STD
X1: CSTNE16M0V530000R0; Crystal_SMD3213-3P; JLC Part Number C341521

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C17.2, C18.2, CN2.4, D1.2 (A), D2.2 (A), D4.2 (A), D6.2 (A), L1.1, R1.2, R2.2, R5.2, R6.2, R10.1, R20.2, U1.5 (VIO), U8.1 (VBAT), U8.19 (VDD), U8.32 (VDD), U8.48 (VDD), U8.64 (VDD), U9.9 (VDD), U12.1; also elsewhere on the board
+3.3VA: C11.1, L1.2, U8.13 (VDDA)
+5V: C13.1, U1.3 (VCC), U11.1; also elsewhere on the board
+36V: H9.1, R8.2, TV1.1 (K); also elsewhere on the board
/ADC1_IN0: U8.14 (PA0); also elsewhere on the board
/ADC1_IN10: C19.1, R8.1, R12.2, U8.8 (PC0)
/ADC2_IN1: U8.15 (PA1); also elsewhere on the board
/ADC2_IN9: C1.2, R1.1, U6.1, U8.27 (PB1)
/ADC3_IN2: C12.2, R20.1, R21.2, U8.16 (PA2)
/CAN_N: R26.1, U1.6 (CANL), U5.1
/CAN_P: R26.2, U1.7 (CANH), U5.2
/CAN_RX: U1.4 (RXD), U8.61 (PB8)
/CAN_STB: U1.8 (S), U8.57 (PB5)
/CAN_TX: U1.1 (TXD), U8.62 (PB9)
/DRV_CAL: U8.38 (PC7); also elsewhere on the board
/DRV_ENABLE: U8.39 (PC8); also elsewhere on the board
/DRV_FAULT: U8.40 (PC9); also elsewhere on the board
/DRV_SPI_NSS: U8.54 (PD2); also elsewhere on the board
/DRV_STA: R11.2, U8.10 (PC2)
/ENCODER_CAL_EN: U8.45 (PA12), U9.4 (CAL_EN)
/ENCODER_OUT: TP9.1, U8.50 (PA15), U9.10 (OUT)
/ENCODER_SPI_NSS: U8.55 (PB3), U9.8 (CSN)
/ENCODER_STA: R15.2, U8.9 (PC1)
/HSE_IN: U8.5 (PH0), X1.1 (OSC1)
/HSE_OUT: U8.6 (PH1), X1.3 (OSC2)
/I2C1_SCL: R5.1, U8.58 (PB6), U10.2
/I2C1_SDA: R6.1, U8.59 (PB7), U10.1
/MCU_STA: R9.2, U8.11 (PC3)
/MT6835_EN: Q1.2 (G), R22.1, U8.44 (PA11)
/RESET: C14.1, R10.2, TP8.1, U8.7 (NRST)
/SPI1_MISO: CN3.2, U8.22 (PA6)
/SPI1_MOSI: CN3.3, U8.23 (PA7)
/SPI1_NSS: CN3.4, U8.26 (PB0)
/SPI1_SCK: CN3.1, U8.21 (PA5)
/SPI3_MISO: U8.52 (PC11), U9.5 (MISO); also elsewhere on the board
/SPI3_MOSI: U8.53 (PC12), U9.6 (MOSI); also elsewhere on the board
/SPI3_SCK: U8.51 (PC10), U9.7 (SCK); also elsewhere on the board
/SWCLK: CN2.1, R3.2, U8.49 (PA14)
/SWDIO: CN2.2, R2.1, U8.46 (PA13)
/TIM1_BKIN: U8.33 (PB12), U8.37 (PC6)
/TIM1_CH1: TP4.1, U8.41 (PA8); also elsewhere on the board
/TIM1_CH1N: TP1.1, U8.34 (PB13); also elsewhere on the board
/TIM1_CH2: TP5.1, U8.42 (PA9); also elsewhere on the board
/TIM1_CH2N: TP2.1, U8.35 (PB14); also elsewhere on the board
/TIM1_CH3: TP6.1, U8.43 (PA10); also elsewhere on the board
/TIM1_CH3N: TP3.1, U8.36 (PB15); also elsewhere on the board
/USART3_RX: CN2.6, U8.25 (PC5)
/USART3_TX: CN2.5, U8.29 (PB10)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C9.1, C11.2, C12.1, C13.2, C14.2, C17.1, C18.1, C19.2, CN2.3, Q1.3 (S), R3.1, R4.2, R7.2, R12.1, R21.1, R22.2, R23.1, R24.2, R25.2, U1.2 (GND), U6.2, U8.18 (VSS), U8.31 (VSS), U8.47 (VSS), U8.63 (VSS), U9.11 (TEST), U9.13 (TEST_EN), U11.2, U12.2, X1.2 (GND); also elsewhere on the board
GND1: H8.1, R4.1, TV1.2 (A); also elsewhere on the board
unnamed: D1.1 (K), R9.1
unnamed: D2.1 (K), R11.1
unnamed: D4.1 (K), R7.1
unnamed: D6.1 (K), R15.1
unnamed: Q1.1 (D), U9.12 (VSS)
unnamed: R23.2, U8.60 (BOOT0)
unnamed: R25.1, U8.28 (PB2)
unnamed: TP7.1, U8.2 (PC13)
unnamed: C9.2, U8.30 (VCAP_1)
unnamed: R24.1, U8.12 (VSSA)

Notes on the sheet:
母线电压
电机温度采样
驱动器温度采样
36v电源输入
CAN
+3.3VA模拟电源滤波
位置传感器
电机驱动A
MT6835_EN的NMOS型号为：WNM2030 选择低导通电阻的
外部高速晶振
状态指示灯

Parts:
C7, C31, C32: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10: 0.1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C15, C33: 0.1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C34, C35: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C21, C22, C23, C24, C25, C26, C29, C36, C37, C38: 10uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C27: 47nF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C28: 1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30: 0.1uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D3: D_Schottky_Small; D_SOD-123
H5, H6, H7: MountingHole_Pad; POWER_PAD; not fitted
L2: 22uH_±20%_1.4A; LQH5BPB220MT0L_IND-SMD_L5.0-W5.0
Q7, Q8, Q9, Q10, Q11, Q12: TPH3R704PL; TPHR8504PL,L1Q
R13: 54.9k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R14: 10k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16, R17: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R18, R19: 5mΩ 1%; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder
U2: TLV76733DRVR; TLV76733DRVR_SON65P200X200X80-7N
U7: DRV8323RSRGZR; DRV8323RS_QFN-48-EP(7x7); JLC Part Number C545497

Connections:
+3.3V: C32.1, C34.1, C35.1, R16.1, R17.1, U2.1 (OUT), U2.2 (SNS), U7.26 (VREF); also elsewhere on the board
+5V: C7.1, C16.1, L2.2, R13.1, U2.4 (EN), U2.6 (IN); also elsewhere on the board
+36V: C10.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C33.1, C36.1, C37.1, C38.1, Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q7.9 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q11.9 (D), U7.6 (VM), U7.7 (VDRAIN), U7.47 (VIN); also elsewhere on the board
/ADC1_IN0: U7.25 (SOA); also elsewhere on the board
/ADC2_IN1: U7.24 (SOB); also elsewhere on the board
/DRV8323RSRGZR/CB: C15.1, U7.44 (CB)
/DRV8323RSRGZR/FB: R13.2, R14.1, U7.1 (FB)
/DRV8323RSRGZR/GHA: Q7.4 (G), U7.8 (GHA)
/DRV8323RSRGZR/GHB: Q9.4 (G), U7.17 (GHB)
/DRV8323RSRGZR/GHC: Q11.4 (G), U7.18 (GHC)
/DRV8323RSRGZR/GLA: Q8.4 (G), U7.10 (GLA)
/DRV8323RSRGZR/GLB: Q10.4 (G), U7.15 (GLB)
/DRV8323RSRGZR/GLC: Q12.4 (G), U7.20 (GLC)
/DRV8323RSRGZR/PHASA: H5.1, Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D), U7.9 (SHA)
/DRV8323RSRGZR/PHASB: H6.1, Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), U7.16 (SHB)
/DRV8323RSRGZR/PHASC: H7.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), Q12.9 (D), U7.19 (SHC)
/DRV8323RSRGZR/SPA: Q8.1 (S), Q8.2 (S), Q8.3 (S), R18.1, U7.11 (SPA)
/DRV8323RSRGZR/SPB: Q10.1 (S), Q10.2 (S), Q10.3 (S), R19.1, U7.14 (SPB)
/DRV8323RSRGZR/SW: C15.2, D3.1 (K), L2.1, U7.45 (SW)
/DRV_CAL: U7.34 (CAL); also elsewhere on the board
/DRV_ENABLE: U7.33 (ENABLE); also elsewhere on the board
/DRV_FAULT: R17.2, U7.28 (nFAULT); also elsewhere on the board
/DRV_SPI_NSS: U7.32 (nSCS); also elsewhere on the board
/SPI3_MISO: R16.2, U7.29 (SDO); also elsewhere on the board
/SPI3_MOSI: U7.30 (SDI); also elsewhere on the board
/SPI3_SCK: U7.31 (SCLK); also elsewhere on the board
/TIM1_CH1: U7.37 (INHA); also elsewhere on the board
/TIM1_CH1N: U7.38 (INLA); also elsewhere on the board
/TIM1_CH2: U7.39 (INHB); also elsewhere on the board
/TIM1_CH2N: U7.40 (INLB); also elsewhere on the board
/TIM1_CH3: U7.41 (INHC); also elsewhere on the board
/TIM1_CH3N: U7.42 (INLC); also elsewhere on the board
GND: C7.2, C16.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, D3.2 (A), R14.2, U2.3 (GND), U2.5 (GND), U2.7 (NC), U7.2 (PGND), U7.27 (DGND), U7.35 (AGND), U7.43 (BGND), U7.49 (EP); also elsewhere on the board
GND1: C10.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C29.2, C36.2, C37.2, C38.2, Q12.1 (S), Q12.2 (S), Q12.3 (S), R18.2, R19.2, U7.12 (SNA), U7.13 (SNB), U7.21 (SPC), U7.22 (SNC); also elsewhere on the board
unnamed: C27.2, U7.4 (CPH)
unnamed: C27.1, U7.3 (CPL)
unnamed: C31.1, U7.36 (DVDD)
unnamed: C28.2, U7.5 (VCP)

Notes on the sheet:
滤波电容
降压电路(3.3V)
电机接口
降压电路（5V）
MOS

Board: 4 copper layers, 50.0 x 42.0 mm, 111 parts (4 on the bottom side), 78 nets.

Other parts of the board:
kibuzzard-692C9A5B: G***; kibuzzard-692C9A5B
kibuzzard-692C9AA1: G***; kibuzzard-692C9AA1

## Code that names these connections

File Firmware/CawDrive.ioc (part):

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Mcu.Name=STM32F446R(C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F446RETx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.Signal=S_TIM1_CH3
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=ENCODER_EN
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=ENCODER_CAL_EN
PA12.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=ENCODER_OUT
PA15.Signal=S_TIM2_CH1_ETR
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED_4
PA5.Signal=GPIO_Output
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Signal=S_TIM3_CH3
PB1.Signal=ADCx_IN9
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB12.Mode=Activate-Break-Input
PB12.Signal=TIM1_BKIN
PB13.GPIOParameters=PinState
PB13.PinState=GPIO_PIN_RESET
PB13.Signal=GPIO_Output
PB14.GPIOParameters=PinState
PB14.PinState=GPIO_PIN_RESET
PB14.Signal=GPIO_Output
PB15.GPIOParameters=PinState
PB15.PinState=GPIO_PIN_RESET
PB15.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PB3.GPIO_Label=ENCODER_SPI_NSS
PB3.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB3.PinState=GPIO_PIN_SET
PB3.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=CAN_STB
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=CAN_Activate
PB8.Signal=CAN1_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN1_TX
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=LED_3
PC1.Signal=GPIO_Output
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC13.Signal=GPIO_Output
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=LED_2
PC2.Signal=GPIO_Output
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=LED_1
PC3.Signal=GPIO_Output
PC5.Mode=Asynchronous
PC5.Signal=USART3_RX
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=TIM1_BREAK
PC6.Signal=GPIO_Output
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=DRV_CAL
PC7.Signal=GPIO_Output
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=DRV_ENABLE
PC8.Signal=GPIO_Output
PC9.GPIOParameters=GPIO_Label
PC9.GPIO_Label=DRV_FAULT
PC9.Signal=GPXTI9
PD2.GPIOParameters=PinState,GPIO_Label
PD2.GPIO_Label=DRV_SPI_NSS
PD2.PinState=GPIO_PIN_SET
PD2.Signal=GPIO_Output
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=160000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2025-07-20 完成FOC速度闭环控制
2025-07-30 增加编码器复位功能
2025-07-30 删除BOM和Gerber目录
2025-11-26 删除固件代码
2025-11-30 更新PCB
2026-02-05 refactor: 将符号表和封装导出到项目中
2026-02-05 fix(CawDrive.kicad_pcb): 修复丝印相关的warning
